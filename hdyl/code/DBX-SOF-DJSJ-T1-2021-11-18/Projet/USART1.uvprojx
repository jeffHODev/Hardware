# Keil uVision project USART1.uvprojx, settings and files
target DBX-DJSJ-T1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DBX-DJSJ-V01 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ../USER/: delay.c driveboard.c main.c stm32f10x_it.c system.c adc.c bsp_led.c pid.c gt208l.c usart3.c fm24c32.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_iwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
