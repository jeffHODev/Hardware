# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: DBX-DJSB-V1.0 +hex
  AfterMake: C:\Keil_v5\C51\HEX2BIN.EXE  .\Output\DBX-DJSB-V1.hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group MAIN
    ./Code/: bsp_init.c main.c eepromf.c
  group Common
    ./Common/: Common.c Delay.c
  group Startup
    ./Startup/: STARTUP.A51
